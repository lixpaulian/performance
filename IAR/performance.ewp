# IAR project performance.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; STM32F746xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\system\include\cmsis; ..\system\include\stm32f7-hal; ..\include; ..\coremark
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: performance.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_HAL_DRIVER; STM32F746xx
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../system/src/cmsis/: system_stm32f7xx.c
  group coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
  group EWARM
    ./: startup_stm32f746xx.s
  group STM32F7xx_HAL_Driver
    ../system/src/stm32f7-hal/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_tim.c
  group User
    ../src/: main.c timing.c xxtea.c
