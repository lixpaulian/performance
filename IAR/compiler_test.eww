<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\performance.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>UART_TwoBoards_ComDMA</project>
        <configuration>STM32746G_DISCOVERY</configuration>
      </member>
      <member>
        <project>UART_TwoBoards_ComIT</project>
        <configuration>STM32746G_DISCOVERY</configuration>
      </member>
      <member>
        <project>UART_TwoBoards_ComPolling</project>
        <configuration>STM32746G_DISCOVERY</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


